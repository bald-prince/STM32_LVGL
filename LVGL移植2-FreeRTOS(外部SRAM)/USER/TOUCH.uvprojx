# Keil uVision project TOUCH.uvprojx, settings and files
target LVGL (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: TOUCH +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F767xx,USE_HAL_DRIVER
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F7xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\SDRAM;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\TOUCH;..\USMART;..\HARDWARE\LVGL\GUI;..\HARDWARE\LVGL\GUI\lvgl;..\HARDWARE\LVGL\GUI\lvgl\src;..\HARDWARE\LVGL\GUI\lvgl\examples\porting;..\HARDWARE\TIMER;..\HARDWARE\LVGL\GUI_APP;..\HARDWARE\LVGL\GUI_APP\demos\stress;..\HARDWARE\LVGL\GUI_APP\demos\music;..\HARDWARE\LVGL\GUI_APP\demos;..\HARDWARE\FreeRTOS\include;..\HARDWARE\FreeRTOS\portable\RVDS\ARM_CM7;..\HARDWARE\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;..\HARDWARE\FreeRTOS;..\HARDWARE\MALLOC
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f7xx_it.c system_stm32f7xx.c lvgl_demo.c
  group CORE
    ../CORE/: core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f767xx.s
  group HALLIB
    ../HALLIB/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sram.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_can.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/LCD/: lcd.c ltdc.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c gt9271.c ott2001a.c touch.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MALLOC/: malloc.c
  group README
    ../: readme.txt
  group HARDWARE/lvgl/example/porting
    ../HARDWARE/LVGL/GUI/lvgl/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
  group HARDWARE/lvgl/src/core
    ../HARDWARE/LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group HARDWARE/lvgl/src/draw
    ../HARDWARE/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../HARDWARE/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group HARDWARE/lvgl/src/extra
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ../HARDWARE/LVGL/GUI/lvgl/src/extra/: lv_extra.c
  group HARDWARE/lvgl/src/font
    ../HARDWARE/LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group HARDWARE/lvgl/src/gpu
    ../HARDWARE/LVGL/GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../HARDWARE/LVGL/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
  group HARDWARE/lvgl/src/hal
    ../HARDWARE/LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group HARDWARE/lvgl/src/misc
    ../HARDWARE/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group HARDWARE/lvgl/src/widgets
    ../HARDWARE/LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group HARDWARE/LVGL/GUI_APP
    ../HARDWARE/LVGL/GUI_APP/demos/stress/: lv_demo_stress.c
    ../HARDWARE/LVGL/GUI_APP/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ../HARDWARE/LVGL/GUI_APP/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
  group HARDWARE/FreeRTOS_CORE
    ../HARDWARE/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group HARDWARE/FreeRTOS_PORT
    ../HARDWARE/FreeRTOS/portable/MemMang/: heap_4.c
    ../HARDWARE/FreeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c
